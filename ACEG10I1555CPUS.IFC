Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\User One\Dropbox\AC_Electronics\10W\ACEG10I1555CPUS\ACEG10I1555CPUS.IFC
Time: 2026-05-21T22:43:03+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
